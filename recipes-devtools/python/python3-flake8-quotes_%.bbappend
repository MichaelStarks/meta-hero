
FILES:${PN} += "${PYTHON_SITEPACKAGES_DIR}/*"
