# Skip dwarfsrcfiles for static libraries
INSANE_SKIP_${PN} += "dwarfsrcfiles"

